Commit message: get feasible grasping pose

File: models/hook/Hook_skew/base.urdf (robot description, URDF)
Before this commit: robot base.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=base.obj scale=0.5 0.5 0.5; visual mesh filename=base.obj scale=0.5 0.5 0.5
