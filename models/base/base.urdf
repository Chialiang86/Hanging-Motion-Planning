Commit message: fix some missing code and adjust shapes in 10/26

File: models/base/base.urdf (robot description, URDF)
Before this commit: robot base.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 0.1 -> 0.0
